# IAR project Project.ewp, settings and files
configuration GD32A10X (ARM, debug)
  General.OGChipSelectEditMenu: GD32A103xB GD GD32A103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32A10X
  ICCARM.CCIncludePath2: ..\..\Firmware\CMSIS; ..\..\Utilities; ..; ..\..\Firmware\GD32A10x_standard_peripheral\Include; ..\..\Firmware\CMSIS\GD\GD32A10x\Include; ..\..\Utilities\LCD_Commom
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  group Application
    ../: gd32a10x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32A10x/Source/: system_gd32a10x.c
  group Doc
    ../: readme.txt
  group Utilities
    ../../Utilities/: gd32a10x_eval.c gd32a10x_lcd_eval.c
    ../../Utilities/LCD_Commom/: lcd_font.c
  group Peripherals
    ../../Firmware/GD32A10x_standard_peripheral/Source/: gd32a10x_adc.c gd32a10x_bkp.c gd32a10x_can.c gd32a10x_crc.c gd32a10x_ctc.c gd32a10x_dac.c gd32a10x_dbg.c gd32a10x_dma.c gd32a10x_exmc.c gd32a10x_exti.c gd32a10x_fmc.c gd32a10x_fwdgt.c gd32a10x_gpio.c gd32a10x_i2c.c gd32a10x_misc.c gd32a10x_pmu.c gd32a10x_rcu.c gd32a10x_rtc.c gd32a10x_spi.c gd32a10x_timer.c gd32a10x_usart.c gd32a10x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32A10x/Source/IAR/: startup_gd32a10x.s
