# IAR project dfu.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32A103xB GD GD32A103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32A10X; GD32A103V_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32A10x\Include; ..\..\..\..\..\Firmware\GD32A10x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32A10x_usbfs_library\device\class\dfu\Include; ..\..\..\..\..\Firmware\GD32A10x_usbfs_library\device\core\Include; ..\..\..\..\..\Firmware\GD32A10x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32A10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBD_Audio.srec
  ILINK.IlinkOutputFile: dfu.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group App
    ../src/: app.c dfu_fmc.c gd25qxx.c gd32a10x_hw.c gd32a10x_it.c inter_flash_if.c nor_flash_if.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32A10x/Source/: system_gd32a10x.c
  group Doc
    ../: readme.txt
  group GD32A10x_EVAL
    ../../../../../Utilities/: gd32a10x_eval.c
  group GD32A10x_StdPeriph
    ../../../../../Firmware/GD32A10x_standard_peripheral/Source/: gd32a10x_ctc.c gd32a10x_exti.c gd32a10x_gpio.c gd32a10x_misc.c gd32a10x_pmu.c gd32a10x_rcu.c gd32a10x_spi.c gd32a10x_timer.c gd32a10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A10x/Source/IAR/: startup_gd32a10x.s
  group USB_Class
    ../../../../../Firmware/GD32A10x_usbfs_library/device/class/dfu/Source/: dfu_core.c dfu_mem.c
  group USB_Device
    ../../../../../Firmware/GD32A10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Drivers
    ../../../../../Firmware/GD32A10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
