# Keil uVision project hid_printer.uvprojx, settings and files
target composite_hid_printer (6130001::V6.13.1::.\ARMCLANG)
  device: GD32A103VB GigaDevice
  pack: GigaDevice.GD32A10x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hid_printer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32A10X GD32A103V_EVAL
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32A10x\Include;..\..\..\..\..\Firmware\GD32A10x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32A10x_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32A10x_usbfs_library\device\core\Include;..\..\..\..\..\Firmware\GD32A10x_usbfs_library\device\class\hid\Include;..\..\..\..\..\Firmware\GD32A10x_usbfs_library\device\class\printer\Include;..\..\..\..\..\Firmware\GD32A10x_usbfs_library\ustd\common;..\..\..\..\..\Firmware\GD32A10x_usbfs_library\ustd\class\hid;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: app.c gd32a10x_hw.c gd32a10x_it.c hid_printer_wrapper.c custom_hid_itf.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32A10x/Source/: system_gd32a10x.c
  group GD32A10x_StdPeriph_Driver
    ../../../../../Firmware/GD32A10x_standard_peripheral/Source/: gd32a10x_dma.c gd32a10x_exti.c gd32a10x_fmc.c gd32a10x_gpio.c gd32a10x_misc.c gd32a10x_pmu.c gd32a10x_rcu.c gd32a10x_timer.c gd32a10x_usart.c gd32a10x_ctc.c
  group GD32A10x_EVAL
    ../../../../../Utilities/: gd32a10x_eval.c
  group USB_Driver
    ../../../../../Firmware/GD32A10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../../../../../Firmware/GD32A10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../../../../../Firmware/GD32A10x_usbfs_library/device/class/hid/Source/: custom_hid_core.c
    ../../../../../Firmware/GD32A10x_usbfs_library/device/class/printer/Source/: printer_core.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A10x/Source/ARM/: startup_gd32a10x.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
