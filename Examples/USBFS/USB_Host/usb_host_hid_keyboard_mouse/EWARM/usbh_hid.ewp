# IAR project usbh_hid.ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32A103xB GD GD32A103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32A10X; GD32A103V_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32A10x\Include; ..\..\..\..\..\Firmware\GD32A10x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32A10x_usbfs_library\driver\Include; ..\..\..\..\..\Firmware\GD32A10x_usbfs_library\host\class\hid\Include; ..\..\..\..\..\Firmware\GD32A10x_usbfs_library\host\core\Include; ..\..\..\..\..\Firmware\GD32A10x_usbfs_library\ustd\class\hid; ..\..\..\..\..\Firmware\GD32A10x_usbfs_library\ustd\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_HID.srec
  ILINK.IlinkOutputFile: usbh_hid.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: gd32a10x_it.c gd32a10x_usb_hw.c main.c usbh_usr.c usbh_usr_lcd.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32A10x/Source/: system_gd32a10x.c
  group Doc
    ../: readme.txt
  group GD32A10x_EVAL
    ../src/: GD32A103V_lcd_eval.c
    ../../../../../Utilities/: gd32a10x_eval.c
    ../../usb_host_msc_udisk/src/: lcd_font.c lcd_log.c
  group GD32A10x_Peripherals
    ../../../../../Firmware/GD32A10x_standard_peripheral/Source/: gd32a10x_dma.c gd32a10x_exmc.c gd32a10x_exti.c gd32a10x_fmc.c gd32a10x_gpio.c gd32a10x_misc.c gd32a10x_pmu.c gd32a10x_rcu.c gd32a10x_timer.c gd32a10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A10x/Source/IAR/: startup_gd32a10x.s
  group USB_Class
    ../../../../../Firmware/GD32A10x_usbfs_library/host/class/hid/Source/: usbh_hid_core.c usbh_standard_hid.c
  group USB_Drivers
    ../../../../../Firmware/GD32A10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32A10x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
