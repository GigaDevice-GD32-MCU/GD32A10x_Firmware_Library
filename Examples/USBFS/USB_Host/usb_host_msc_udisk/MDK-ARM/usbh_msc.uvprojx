# Keil uVision project usbh_msc.uvprojx, settings and files
target usbh_msc (6130001::V6.13.1::.\ARMCLANG)
  device: GD32A103VB GigaDevice
  pack: GigaDevice.GD32A10x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usbh_msc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32A10X  GD32A103V_EVAL
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32A10x\Include;..\..\..\..\..\Firmware\GD32A10x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32A10x_usbfs_library\driver\Include;..\..\..\..\..\Firmware\GD32A10x_usbfs_library\host\core\Include;..\..\..\..\..\Firmware\GD32A10x_usbfs_library\host\class\msc\Include;..\..\..\..\..\Firmware\GD32A10x_usbfs_library\ustd\common;..\..\..\..\..\Firmware\GD32A10x_usbfs_library\ustd\class\msc;..\..\..\..\..\Utilities;..\..\..\..\..\Utilities\LCD_common;..\..\..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../src/: gd32a10x_it.c gd32a10x_usb_hw.c main.c usbh_usr.c
  group CMSIS
    ../../../../../Firmware/CMSIS/GD/GD32A10x/Source/: system_gd32a10x.c
  group GD32A10x_StdPeriph_Driver
    ../../../../../Firmware/GD32A10x_standard_peripheral/Source/: gd32a10x_exti.c gd32a10x_fmc.c gd32a10x_gpio.c gd32a10x_misc.c gd32a10x_pmu.c gd32a10x_rcu.c gd32a10x_timer.c gd32a10x_usart.c gd32a10x_exmc.c
  group GD32A10x_EVAL
    ../src/: lcd_font.c lcd_log.c GD32A103V_lcd_eval.c
    ../../../../../Utilities/: gd32a10x_eval.c
  group USB_Drivers
    ../../../../../Firmware/GD32A10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group USB_Host
    ../../../../../Firmware/GD32A10x_usbfs_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../../../../../Firmware/GD32A10x_usbfs_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32A10x/Source/ARM/: startup_gd32a10x.s
  group FAT_FS
    ../../../../../Utilities/Third_Party/fat_fs/src/: ff.c ffunicode.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
